Properties of the parts of a building model (IFC4)

# File
Description: Raumtemperaturregler, Heizen/Kühlen, Aufputz, 230 VAC, 3-stufiger Lüfterausgang, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MA200202, Raumtemperaturregler, Heizen/Kühlen, Aufputz, 230 VAC, 3-stufiger Lüfterausgang
In: Raum
Description: Klimaregler „Heizen oder Kühlen“ für Fancoil-Geräte, Luftverteilsysteme oder Teilklimaanlagen mit Heiz-/Kühlumschaltung und neutraler Zone im 4-Rohrsystem für Hotel-, Wohn- und Geschäftsräume. Das Gerät verfügt über einen Umschaltkontakt mit neutraler Zone und 2x Hilfsausgänge "Ein/Aus". Der Einstellbereich kann mechanisch unter dem Knopf mit den Einstellfahnen begrenzt werden. Aufputz-/Wandmontage oder mittels Adapterplatte auf UP-Dose.; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MA200202; ModelLabel: KTBSB-112.070; GlobalTradeItemNumber: 4050528049902; ProductURL: https://alre.de/produkt_MA200202
Pset_Specification - NominalLength: 0.1107 m; NominalWidth: 0.11 m; NominalDepth: 0.026 m; NetWeight: 0.139
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: weiß; Breite: 110; Höhe: 110.7; Tiefe: 26; RAL-Nummer: 9010; Anschluss: sonstige; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Wechsler (NO/NC); Messbereich: 5; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Bimetall; Klasse des Temperaturreglers: I; Schutzart (NEMA): sonstige; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 1; Temperatur ablesbar: no; Max. Kontaktbelastung: 6; Differenzwert: 1; Sensor extern: no; Thermische Rückkopplung: parallel; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MA200202.pdf
